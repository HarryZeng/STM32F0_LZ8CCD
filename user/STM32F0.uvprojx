# Keil uVision project STM32F0.uvprojx, settings and files
target STM32F031K6U6 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F031K6Ux STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LZ8CCD_STM32F031 +hex
  c flags: v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F0XX_LD
  c include: ..\Peripherals\inc;..\user;..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\Libraries\STM32F0xx_StdPeriph_Driver\src;..\Libraries\CMSIS\Device\ST\STM32F0xx;..\Libraries\CMSIS\Device\ST\STM32F0xx\Source\Templates\arm;..\Libraries\CMSIS\Device\ST\STM32F0xx\Include;..\Libraries\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Lib_CMSIS
    ../Libraries/CMSIS/Include/: core_cm0.h
    ../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f0xx.s
    ../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group Lib_Driver
    ../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_dma.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c
  group Peripherals
    ../Peripherals/src/: display.c key.c menu.c flash.c SelfStudy.c
  group user
    ./: main.c BSP_Init.c
    ../Peripherals/src/: project.c
